#include "ime.h"
#include <cstring>
namespace inkdesk {
struct Entry{const char*py;const char*words;};
// Small, authored seed lexicon. No prediction, segmentation, personal/cloud data.
// '|' separates candidates; phrases require full concatenated pinyin.
static constexpr Entry dictionary[]={
 {"a","啊|阿"},{"ai","爱|爱好|矮|哎"},{"an","安|按|暗|案"},{"ang","昂"},{"ao","奥|熬|傲"},
 {"ba","把|吧|八|爸|巴|拔|罢"},{"bai","白|百|摆|拜"},{"ban","半|办|班|版|般|板"},{"bang","帮|棒|邦"},
 {"bao","包|报|保|宝|抱"},{"bei","被|北|备|背|杯|倍"},{"ben","本|笨|奔"},{"beng","蹦|崩"},
 {"bi","比|笔|必|币|避|毕"},{"bian","变|边|便|编|遍"},{"biao","表|标"},{"bie","别"},
 {"bin","宾|滨"},{"bing","并|病|冰|饼"},{"bo","波|播|博|拨|薄"},{"bu","不|部|步|布|补"},
 {"ca","擦"},{"cai","才|菜|采|财|彩"},{"can","参|餐|残"},{"cang","藏|仓"},{"cao","草|操"},
 {"ce","测|册|策"},{"ceng","层|曾"},{"cha","查|茶|差|插"},{"chai","拆|柴"},{"chan","产|禅|馋"},
 {"chang","长|常|场|唱|厂"},{"chao","超|朝|潮|炒"},{"che","车|撤"},{"chen","陈|晨|沉|趁"},
 {"cheng","成|城|程|称|承|乘"},{"chi","吃|持|迟|尺|池"},{"chong","重|冲|充|虫"},{"chou","抽|愁|丑"},
 {"chu","出|处|初|除|楚"},{"chuan","传|船|穿|串"},{"chuang","窗|床|创"},{"chun","春|纯"},
 {"ci","次|此|词|辞"},{"cong","从|聪|葱"},{"cou","凑"},{"cu","粗|促"},{"cun","存|村|寸"},{"cuo","错|措"},
 {"da","大|打|答|达"},{"dai","待|带|代|戴|袋"},{"dan","但|单|蛋|淡"},{"dang","当|档|挡"},
 {"dao","到|道|倒|导|岛"},{"de","的|得|地"},{"deng","等|灯|登"},{"di","地|第|低|底|滴"},
 {"dian","点|电|店|典"},{"diao","调|掉|钓"},{"die","叠|跌"},{"ding","定|顶|订|丁"},
 {"diu","丢"},{"dong","动|东|懂|冬"},{"dou","都|豆|斗"},{"du","读|度|独|都|堵"},
 {"duan","段|短|断|端"},{"dui","对|队|堆"},{"duo","多|朵|躲"},
 {"e","额|饿|恶|鹅"},{"en","嗯|恩"},{"er","而|二|儿|耳"},
 {"fa","发|法|罚"},{"fan","反|饭|翻|凡"},{"fang","方|放|房|访"},{"fei","非|费|飞|肥"},
 {"fen","分|份|粉|奋"},{"feng","风|封|峰|丰"},{"fo","佛"},{"fou","否"},{"fu","服|复|付|福|父|负"},
 {"gai","该|改|盖"},{"gan","干|感|赶|敢"},{"gang","刚|港|钢"},{"gao","高|告|稿|搞"},
 {"ge","个|各|歌|格"},{"gei","给"},{"gen","跟|根"},{"geng","更|耕"},{"gong","工|公|共|功"},
 {"gou","够|购|狗"},{"gu","古|故|股|顾"},{"gua","挂|瓜"},{"guai","怪|乖"},{"guan","关|管|观|馆"},
 {"guang","光|广"},{"gui","贵|归|规|柜"},{"gun","滚"},{"guo","过|国|果|锅"},
 {"ha","哈"},{"hai","还|海|孩|害"},{"han","汉|寒|含|喊"},{"hang","行|航"},{"hao","好|号|毫|耗|浩"},
 {"he","和|喝|合|河|何"},{"hei","黑"},{"hen","很|狠|恨"},{"heng","横|恒"},{"hong","红|宏|洪"},
 {"hou","后|候|厚|猴"},{"hu","户|湖|互|乎|呼"},{"hua","话|花|画|化|华"},{"huai","坏|怀"},
 {"huan","换|还|欢|环"},{"huang","黄|慌|皇"},{"hui","会|回|灰|汇|挥"},{"hun","混|婚"},{"huo","或|活|火|货"},
 {"ji","记|机|几|及|级|即|己|集"},{"jia","家|加|价|假|佳"},{"jian","见|件|间|建|减|简"},
 {"jiang","将|讲|江|降|奖"},{"jiao","交|教|叫|角|较"},{"jie","接|节|解|街|界|结"},{"jin","今|进|近|金|紧"},
 {"jing","经|精|静|景|京|净"},{"jiong","窘"},{"jiu","就|九|久|酒|旧"},{"ju","居|局|句|具|举"},
 {"juan","卷|捐"},{"jue","决|觉|绝"},{"jun","军|均|君"},
 {"ka","卡|咖"},{"kai","开|凯"},{"kan","看|刊"},{"kang","康|抗"},{"kao","考|靠|烤"},
 {"ke","可|课|科|客|刻"},{"ken","肯"},{"keng","坑"},{"kong","空|孔"},{"kou","口|扣"},
 {"ku","苦|库|酷"},{"kua","跨|夸"},{"kuai","快|块"},{"kuan","宽|款"},{"kuang","况|框|矿"},
 {"kui","亏|愧"},{"kun","困"},{"kuo","扩|阔"},
 {"la","拉|啦|辣"},{"lai","来|赖"},{"lan","蓝|兰|栏|懒"},{"lang","浪|朗|狼"},{"lao","老|劳|牢"},
 {"le","了|乐"},{"lei","类|累|泪|雷"},{"leng","冷"},{"li","里|理|力|利|离|李|立"},
 {"lia","俩"},{"lian","连|联|脸|练"},{"liang","两|量|亮|良"},{"liao","聊|料|了"},{"lie","列|烈"},
 {"lin","林|临|邻"},{"ling","零|另|领|灵"},{"liu","刘|六|流|留"},{"long","龙|隆"},{"lou","楼|漏"},
 {"lu","路|录|陆|露"},{"lv","绿|旅|率|律|吕"},{"luan","乱"},{"lun","论|轮"},{"luo","落|罗|洛"},
 {"ma","吗|妈|马|码"},{"mai","买|卖|麦"},{"man","慢|满|漫"},{"mang","忙|盲"},{"mao","猫|毛|冒"},
 {"me","么"},{"mei","没|每|美|妹|梅"},{"men","们|门"},{"meng","梦|蒙|猛"},{"mi","米|密|迷"},
 {"mian","面|免|棉"},{"miao","秒|描|妙|苗"},{"mie","灭"},{"min","民|敏"},{"ming","明|名|命"},
 {"mo","末|莫|墨|模|摸"},{"mou","某"},{"mu","目|木|母|幕"},
 {"na","那|拿|哪"},{"nai","奶|耐|乃"},{"nan","南|难|男"},{"nang","囊"},{"nao","脑|闹"},
 {"ne","呢"},{"nei","内"},{"nen","嫩"},{"neng","能"},{"ni","你|尼|泥|拟|逆|妮"},
 {"nian","年|念"},{"niang","娘"},{"niao","鸟"},{"nie","捏"},{"nin","您"},{"ning","宁|凝"},
 {"niu","牛|纽"},{"nong","农|弄|浓"},{"nu","努|怒"},{"nv","女"},{"nuan","暖"},{"nuo","诺|挪"},
 {"o","哦"},{"ou","偶|欧"},{"pa","怕|爬|趴"},{"pai","排|拍|派"},{"pan","盘|判|盼"},
 {"pang","旁|胖"},{"pao","跑|泡"},{"pei","配|陪|培"},{"pen","盆|喷"},{"peng","朋|碰|棚"},
 {"pi","批|皮|匹"},{"pian","片|篇|偏"},{"piao","票|漂"},{"pin","品|拼|频"},{"ping","平|评|屏|瓶"},
 {"po","破|坡"},{"pu","普|铺|谱"},{"qi","起|期|其|气|七|器|齐"},{"qia","恰|卡"},{"qian","前|钱|千|签|浅"},
 {"qiang","强|墙|枪"},{"qiao","桥|巧|敲"},{"qie","切|且"},{"qin","亲|琴|勤"},{"qing","请|清|情|轻|青"},
 {"qiong","穷"},{"qiu","秋|求|球"},{"qu","去|区|取|曲"},{"quan","全|权|圈"},{"que","却|确|缺"},{"qun","群"},
 {"ran","然|染"},{"rang","让"},{"rao","绕|饶"},{"re","热"},{"ren","人|任|认|仁"},{"reng","仍|扔"},
 {"ri","日"},{"rong","容|荣|融"},{"rou","肉|柔"},{"ru","如|入"},{"ruan","软"},{"rui","瑞|锐"},{"run","润"},{"ruo","若|弱"},
 {"sa","撒|洒"},{"sai","赛|塞"},{"san","三|散|伞"},{"sang","桑"},{"sao","扫"},{"se","色"},{"sen","森"},
 {"sha","沙|啥|傻"},{"shai","晒"},{"shan","山|善|删|闪"},{"shang","上|商|伤|尚"},{"shao","少|稍|烧"},
 {"she","设|舍|社"},{"shen","深|身|神|审|什"},{"sheng","生|声|省|升|胜"},{"shi","是|时|事|十|使|市|诗|式|世|试"},
 {"shou","手|收|受|首"},{"shu","书|数|树|输|属|舒"},{"shua","刷|耍"},{"shuai","帅|摔"},
 {"shuan","栓"},{"shuang","双|爽"},{"shui","水|谁|睡"},{"shun","顺"},{"shuo","说|硕"},
 {"si","四|思|司|似|丝"},{"song","送|松|宋"},{"sou","搜"},{"su","速|素|苏"},{"suan","算|酸"},
 {"sui","随|岁|虽"},{"sun","孙|损"},{"suo","所|索|锁"},
 {"ta","他|她|它|塔"},{"tai","太|台|态"},{"tan","谈|探|弹"},{"tang","堂|糖|汤|唐"},{"tao","套|讨|桃"},
 {"te","特"},{"teng","腾|疼"},{"ti","提|题|体|替"},{"tian","天|田|填|甜"},{"tiao","条|调|跳"},
 {"tie","贴|铁"},{"ting","听|停|庭"},{"tong","同|通|童|痛"},{"tou","头|投|透"},{"tu","图|土|突"},
 {"tuan","团"},{"tui","推|退"},{"tun","吞"},{"tuo","拖|托|脱"},
 {"wa","挖|娃|瓦"},{"wai","外|歪"},{"wan","完|万|晚|玩|弯"},{"wang","王|往|网|忘|望"},
 {"wei","为|位|未|微|围|维"},{"wen","问|文|温|闻"},{"weng","翁"},{"wo","我|握|窝"},{"wu","无|五|物|务|午|屋"},
 {"xi","西|希|系|习|喜|细|息"},{"xia","下|夏|虾"},{"xian","先|现|线|闲|显|限"},{"xiang","想|向|像|相|项|香"},
 {"xiao","小|笑|校|消|晓"},{"xie","写|些|谢|鞋|协"},{"xin","新|心|信|欣"},{"xing","行|星|性|醒|形"},
 {"xiong","兄|雄|熊"},{"xiu","修|休|秀"},{"xu","需|许|续|序|虚"},{"xuan","选|宣|玄"},{"xue","学|雪|血"},{"xun","寻|讯|训"},
 {"ya","呀|压|亚|牙"},{"yan","言|眼|研|颜|验|严"},{"yang","样|阳|养|杨|羊"},{"yao","要|药|摇|遥"},
 {"ye","也|页|夜|业|叶"},{"yi","一|以|已|意|衣|易|议|依"},{"yin","因|音|引|印|银"},{"ying","应|英|影|赢"},
 {"yo","哟"},{"yong","用|永|拥|勇"},{"you","有|又|友|由|右|优|游"},{"yu","于|与|语|雨|余|鱼"},
 {"yuan","元|原|远|员|院|圆"},{"yue","月|阅|约|越|乐"},{"yun","云|运|允"},
 {"za","杂|砸"},{"zai","在|再|载"},{"zan","咱|赞"},{"zang","脏|藏"},{"zao","早|造|澡"},
 {"ze","则|择|泽"},{"zei","贼"},{"zen","怎"},{"zeng","增|曾|赠"},{"zha","扎|炸|渣"},
 {"zhai","宅|摘|窄"},{"zhan","站|展|占|战"},{"zhang","张|长|章|掌"},{"zhao","找|照|招|朝"},
 {"zhe","这|着|者|哲|折"},{"zhen","真|阵|镇|针"},{"zheng","正|整|政|争|证"},
 {"zhi","知|只|之|直|纸|至|指|制|志|值"},{"zhong","中|种|重|钟|众"},{"zhou","周|州|粥"},
 {"zhu","主|住|助|注|竹|朱"},{"zhua","抓"},{"zhuan","转|专|赚"},{"zhuang","装|状|庄"},
 {"zhui","追|坠"},{"zhun","准"},{"zhuo","桌|捉"},{"zi","字|自|子|资|紫"},{"zong","总|宗"},
 {"zou","走|奏"},{"zu","组|足|租|祖"},{"zuan","钻"},{"zui","最|嘴"},{"zun","尊"},{"zuo","做|作|左|坐|昨"},
 {"nihao","你好"},{"xiexie","谢谢"},{"zaijian","再见"},{"jintian","今天"},{"mingtian","明天"},
 {"houtian","后天"},{"zuotian","昨天"},{"jishi","记事|及时"},{"biji","笔记"},{"daiban","待办"},
 {"yuedu","阅读"},{"dushu","读书"},{"dianzishu","电子书"},{"huiyi","会议|回忆"},{"gongzuo","工作"},
 {"xuexi","学习"},{"jihua","计划"},{"wancheng","完成"},{"baocun","保存"},{"zhongwen","中文"},
 {"shenzhen","深圳"},{"shijian","时间|实践"},{"shuru","输入"},{"ceshi","测试"},{"qingxi","清晰"},
};
static const Entry*lookup(const char*py){for(const auto&e:dictionary)if(std::strcmp(e.py,py)==0)return &e;return nullptr;}
bool Pinyin::letter(char c){if(c<'a'||c>'z')return false;if(!raw_.append(&c,1))return false;page_=0;++revision_;return true;}
bool Pinyin::backspace(){if(!raw_.pop())return false;page_=0;++revision_;return true;}
void Pinyin::clear(){raw_.clear();page_=0;++revision_;}
size_t Pinyin::count()const{const auto*e=lookup(raw_.c_str());if(!e||!*e->words)return 0;size_t n=1;for(auto*p=e->words;*p;++p)if(*p=='|')++n;return n;}
void Pinyin::nextPage(){size_t pages=(count()+kPageSize-1)/kPageSize;page_=pages?(page_+1)%pages:0;++revision_;}
bool Pinyin::candidate(size_t index,Text<48>&out)const{out.clear();if(index>=kPageSize)return false;const auto*e=lookup(raw_.c_str());if(!e)return false;size_t target=page_*kPageSize+index;const char*s=e->words;while(target&&*s){if(*s++=='|')--target;}if(target||!*s)return false;const char*end=std::strchr(s,'|');return out.assign(s,end?static_cast<size_t>(end-s):std::strlen(s));}
size_t Pinyin::dictionarySize(){return sizeof(dictionary)/sizeof(dictionary[0]);}
}
